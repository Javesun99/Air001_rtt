# Keil uVision project Project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,AIR001_DEV
  c include: ..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\BSP\AIR001_Core_Board;..\..\..\..\..\Libraries\CMSIS\Device\AIR001xx\Include;..\Inc;..\..\..\..\..\Libraries\AIR001xx_HAL_Driver\Inc;.cmsis\include;RTE\_Project;.eide\deps;..\rtthread\include;..\rtthread\components\finsh;..\MDK-ARM
  asm define: USE_HAL_DRIVER,AIR001_DEV
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group rtthread/libcpu
    ../rtthread/libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group rtthread/core
    ../rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../rtthread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group Drivers/AIR001xx_HAL_Driver
    ../../../../../Libraries/AIR001xx_HAL_Driver/Src/: air001xx_hal_cortex.c air001xx_hal_dma.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_iwdg.c air001xx_hal_pwr.c air001xx_hal_rcc_ex.c air001xx_hal_rcc.c air001xx_hal_uart.c air001xx_hal.c
  group Common
    ../Src/: system_air001xx.c
    ./: startup_air001_dev.s
  group BSP/Air001_Core_Board
    ../../../../../Libraries/BSP/AIR001_Core_Board/: air001_Core_Board.c
  group Application/User
    ../Src/: air001xx_hal_msp.c air001xx_it.c board.c main.c
    ./: ringbuff.c ringbuff.h
software components: CMSIS:CORE 5.5.0
